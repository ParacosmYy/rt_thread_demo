# Keil uVision project Fire_RT-Thread.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: YH-RT-Thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\rtthread\3.0.3\bsp;..\rtthread\3.0.3\components\finsh;..\rtthread\3.0.3\include;..\rtthread\3.0.3\include\libc;..\gsthread\src;..\gsthread\libcpu;..\gsthread\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c gsconfig.h
  group rtt/ports
    ../gsthread/libcpu/arm/cortex-m4/: context_rvds.s cpuport.c
  group rtt/source
    ../gsthread/src/: scheduler.c thread.c list.c
  group doc
    ../Doc/: readm.txt
  group include
    ../gsthread/include/: gsdef.h gshw.h gsservice.h gsthread.h list.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
